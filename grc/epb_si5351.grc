<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>si5351_c0</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>label</key><value>Si5351 C0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>200e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>si5351_c1</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Si5351 C1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>200e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>si5351_c2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Si5351 C2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>200e6</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>53000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>address</key><value>'127.0.0.1'</value></param>
<param><key>c0</key><value>si5351_c0</value></param>
<param><key>c1</key><value>si5351_c1</value></param>
<param><key>c2</key><value>si5351_c2</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr
import socket

class blk(gr.basic_block):
    """Embedded Python Block example - Si5351"""

    def __init__(self, address='127.0.0.1', port=53000, c0=0, c1=0, c2=0):
        gr.basic_block.__init__(
            self,
            name='Si5351',
            in_sig=None,
            out_sig=None
        )
        self._address = address
        self._port = port
        self._c0 = c0
        self._c1 = c1
        self._c2 = c2

        try:
            self._connect()
            self._send_c(0, self._c0)
            self._send_c(1, self._c1)
            self._send_c(2, self._c2)
        except:
            pass

    def _connect(self):
        print('connecting to %s:%d' % (self._address, self._port))
        self._client = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
        self._client.connect((self._address, self._port))
        self._stream = self._client.makefile(mode='rw')

    def _send_c(self, index, freq):
        try:
            self._stream.write('C%d:%d\n' % (index, int(freq)))
            self._stream.flush()
        except:
            self._connect()
            self._stream.write('C%d:%d\n' % (index, int(freq)))
            self._stream.flush()

    @property
    def c0(self):
        return self._c0

    @c0.setter
    def c0(self, c0):
        self._c0 = c0
        self._send_c(0, self._c0)

    @property
    def c1(self):
        return self._c1

    @c1.setter
    def c1(self, c1):
        self._c1 = c1
        self._send_c(1, self._c1)

    @property
    def c2(self):
        return self._c2

    @c2.setter
    def c2(self, c2):
        self._c2 = c2
        self._send_c(2, self._c2)
</value></param>
<param><key>port</key><value>53000</value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print</sink_key></connection>
</flow_graph>
